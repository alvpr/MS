options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Rx_Base
    output_language: python
    title: Rx_Base
  states: {}

blocks:
- name: d
  id: variable
  parameters:
    value: 1/(2**(1/2))
  states: {}
- name: dec_dummy
  id: variable_dummy_decoder_def
  parameters:
    framebits: 12*8
    ndim: '0'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 800e6
  states: {}
- name: gain_rx
  id: variable
  parameters:
    value: '30'
  states: {}
- name: mark_delay
  id: variable
  parameters:
    value: '104'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pld_const
  id: variable_constellation_rect
  parameters:
    const_points: '[d+d*1j, -d+d*1j,-d-d*1j, d-d*1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), eb, 11*sps*nfilts)
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(hdr_const, True, sps, True, eb, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_pf
  id: variable
  parameters:
    value: '2'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: 6.28/200
  states: {}
- name: x
  id: variable_adaptive_algorithm
  parameters:
    cons: pld_const
    modulus: '1'
    step_size: '10e-6'
    type: cma
  states: {}
- name: TFMv5_crc32_check_1
  id: TFMv5_crc32_check
  parameters:
    npackets: '1000'
    r1: '0'
    r2: '0'
    r3: '0'
  states: {}
- name: TFMv5_energy_scale_0
  id: TFMv5_energy_scale
  parameters:
    eavg: '1'
    init_scale: '12'
    length: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: pld_const.bits_per_symbol()
    l: '8'
    len_tag_key: '"payload symbols"'
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"time_est"'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: byte
  states: {}
- name: digital_cma_equalizer_cc_0_0_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '10e-6'
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: pld_const
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: hdr_const
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.7'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: hdr_const.arity()
    w: 6.28/100
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: pld_const.arity()
    w: 6.28/100
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: len(pld_const.points())
  states: {}
- name: digital_diff_decoder_bb_0_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '256'
    rolloff: eb
    samps_per_sym: sps
    type: cc
    w: '2e-3'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: (hdr_format.header_nbits() * int(1.0/hdr_dec.rate())) //  hdr_const.bits_per_symbol()
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'True'
    samp_rate: '1'
    special_tags: '[]'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"amp_est"'
    type: complex
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw*2
    max_dev: '1.5'
    osps: sps_pf
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: fec_generic_decoder_0_0
  id: fec_generic_decoder
  parameters:
    decoder: dec_dummy
    itype: float
    otype: byte
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: hdr_dec
  id: parameter
  parameters:
    label: Header FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0,2)
  states: {}
- name: mod_header_0_0
  id: virtual_sink
  parameters:
    stream_id: Header
  states: {}
- name: mod_header_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: Const
    name: '"Header Constellation"'
    size: '128'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: Const
    name: '"Payload Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: I
    label2: Q
    name: '"Polyphase Out"'
    size: 1024*4
    srate: 1e6
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rx_mod_header_0_0
  id: virtual_source
  parameters:
    stream_id: Header
  states: {}
- name: rx_mod_header_0_1
  id: virtual_source
  parameters:
    stream_id: Payload
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: disabled
    dev_addr: '"serial=30F9A6B"'
    dev_args: '""'
    gain0: gain_rx
    iq_imbal_enb0: disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Rx Symbols
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Rx Symbols
  states: {}

connections:
- [TFMv5_crc32_check_1, out, blocks_message_debug_0, print]
- [TFMv5_energy_scale_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_repack_bits_bb_0_1, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tag_gate_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, TFMv5_crc32_check_1, in]
- [digital_cma_equalizer_cc_0_0_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_generic_decoder_0_0, '0']
- [digital_corr_est_cc_0, '0', blocks_tag_gate_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_diff_decoder_bb_0_0_0_0, '0', digital_protocol_parser_b_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_corr_est_cc_0, '0']
- [digital_header_payload_demux_0, '0', mod_header_0_0, '0']
- [digital_header_payload_demux_0, '1', mod_header_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [fec_generic_decoder_0_0, '0', digital_diff_decoder_bb_0_0_0_0, '0']
- [rx_mod_header_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [rx_mod_header_0_1, '0', digital_costas_loop_cc_0_0_0, '0']
- [uhd_usrp_source_0, '0', TFMv5_energy_scale_0, '0']
- [virtual_source_1, '0', digital_header_payload_demux_0, '0']

metadata:
  file_format: 1
