options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Dipolos_Canal_Principal
    output_language: python
    title: Dipolos_Canal_Principal
  states: {}

blocks:
- name: Mod
  id: variable_qtgui_range
  parameters:
    gui_hint: (6,0,1,2)
    rangeType: int
    start: '0'
    step: '1'
    stop: '3'
    value: '0'
  states: {}
- name: d
  id: variable
  parameters:
    value: 1/(2**(1/2))
  states: {}
- name: dec_dummy
  id: variable_dummy_decoder_def
  parameters:
    framebits: 18*8
    ndim: '0'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: filt_delay
  id: variable
  parameters:
    value: int(1+(taps_per_filt-1)//2)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1.06e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: gain_rx
  id: variable
  parameters:
    value: '30'
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: gain_tx
    start: '30'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: mark_delay
  id: variable
  parameters:
    value: '104'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.0001'
    stop: '2'
    value: '0'
  states: {}
- name: pld_const_16qam
  id: variable
  parameters:
    value: digital.qam_constellation(16,True,digital.mod_codes.GRAY_CODE,False)
  states: {}
- name: pld_const_64qam
  id: variable
  parameters:
    value: digital.qam_constellation(64,True,digital.mod_codes.GRAY_CODE,False)
  states: {}
- name: pld_const_qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[d+d*1j, -d+d*1j,-d-d*1j, d-d*1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: psf_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 15*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), eb, 11*sps*nfilts)
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(hdr_const, True, sps, True, eb, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scale_16QAM
  id: variable
  parameters:
    value: '0.9471'
  states: {}
- name: scale_64QAM
  id: variable
  parameters:
    value: '0.9393'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[0.9,0,0,0,0.3,0,0,0,0.312]'
  states: {}
- name: taps_0
  id: variable
  parameters:
    value: '[0.97,0,0,0,0.243]'
  states: {}
- name: taps_1
  id: variable
  parameters:
    value: '[0.3,0,0,0,0.9,0,0,0,0.312]'
  states: {}
- name: taps_per_filt
  id: variable
  parameters:
    value: int(len(psf_taps)/nfilts)
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: 6.28/200
  states: {}
- name: TFMv5_crc32_check_0
  id: TFMv5_crc32_check
  parameters:
    npackets: '2000'
    r1: '0.5'
    r2: '0.5'
    r3: '0.5'
  states: {}
- name: TFMv5_dispersion_probe_0_1_0_0
  id: TFMv5_dispersion_probe
  parameters:
    constellation: '0'
    length: samp_rate/2
    length_init: '0'
    th1: '0.02'
    th2: '0.03'
    th3: '0.04'
    th4: '0.05'
    th5: '0.06'
    th6: '0.07'
  states: {}
- name: TFMv5_dispersion_probe_0_1_0_0_0
  id: TFMv5_dispersion_probe
  parameters:
    constellation: '1'
    length: samp_rate/2
    length_init: '0'
    th1: '0.02'
    th2: '0.03'
    th3: '0.04'
    th4: '0.05'
    th5: '0.06'
    th6: '0.07'
  states: {}
- name: TFMv5_dispersion_probe_0_1_0_0_0_0
  id: TFMv5_dispersion_probe
  parameters:
    constellation: '2'
    length: samp_rate/2
    length_init: '0'
    th1: '0.02'
    th2: '0.03'
    th3: '0.04'
    th4: '0.05'
    th5: '0.06'
    th6: '0.07'
  states: {}
- name: TFMv5_dispersion_probe_0_1_0_0_0_0_0
  id: TFMv5_dispersion_probe
  parameters:
    constellation: '3'
    length: samp_rate/2
    length_init: '0'
    th1: '0.02'
    th2: '0.03'
    th3: '0.04'
    th4: '0.05'
    th5: '0.06'
    th6: '0.07'
  states: {}
- name: TFMv5_energy_scale_0
  id: TFMv5_energy_scale
  parameters:
    eavg: '1'
    init_scale: '1'
    length: samp_rate*2
  states: {}
- name: TFMv5_header_payload_demux_am_0
  id: TFMv5_header_payload_demux_am
  parameters:
    guard_interval: '0'
    header_len: (hdr_format_bpsk.header_nbits()) //  hdr_const.bits_per_symbol()
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'True'
    samp_rate: '1'
    special_tags: '[]'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"amp_est"'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: scale_64QAM
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/scale_64QAM*1.15
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/scale_16QAM*1.118
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: scale_16QAM
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: pld_const_qpsk.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: pld_const_16qam.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: pld_const_64qam.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: pld_const_qpsk.bits_per_symbol()
    l: '8'
    len_tag_key: '"payload symbols"'
  states: {}
- name: blocks_repack_bits_bb_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: hdr_const.bits_per_symbol()
    l: '8'
    len_tag_key: '"payload symbols"'
  states: {}
- name: blocks_repack_bits_bb_0_1_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: pld_const_16qam.bits_per_symbol()
    l: '8'
    len_tag_key: '"payload symbols"'
  states: {}
- name: blocks_repack_bits_bb_0_1_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: pld_const_64qam.bits_per_symbol()
    l: '8'
    len_tag_key: '"payload symbols"'
  states: {}
- name: blocks_repack_bits_bb_0_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_3_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: Mod
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '60'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '124'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '252'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '380'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"time_est"'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_1
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_1_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_1_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Tx
    num_tabs: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: pld_const_qpsk.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: pld_const_16qam.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_1_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: pld_const_64qam.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_2
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_2_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_cma_equalizer_cc_0_0_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '1e-6'
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_cma_equalizer_cc_0_0_0_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '1e-6'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_cma_equalizer_cc_0_0_0_0_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '1e-6'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_cma_equalizer_cc_0_0_0_0_0_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '1e-6'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_cma_equalizer_cc_0_0_0_1
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1.5655'
    mu: '1e-6'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: pld_const_64qam.base()
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: pld_const_qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: hdr_const
  states: {}
- name: digital_constellation_decoder_cb_0_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: pld_const_16qam
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: pld_const_16qam
    fmax: '0.5'
    fmin: '-0.5'
    loop_bw: 6.28/100
  states: {}
- name: digital_constellation_receiver_cb_0_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: pld_const_64qam.base()
    fmax: '0.5'
    fmin: '-0.5'
    loop_bw: 6.28/100
    showports: 'True'
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: hdr_const
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.5'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: hdr_const.arity()
    w: 6.28/100
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: pld_const_qpsk.arity()
    w: 6.28/100
  states: {}
- name: digital_costas_loop_cc_0_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: hdr_const.arity()
    w: 6.28/100
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: len(pld_const_qpsk.points())
  states: {}
- name: digital_diff_decoder_bb_0_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_diff_decoder_bb_0_0_0_1
  id: digital_diff_decoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_diff_decoder_bb_0_0_0_2
  id: digital_diff_decoder_bb
  parameters:
    modulus: len(pld_const_16qam.points())
  states: {}
- name: digital_diff_decoder_bb_0_0_0_2_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: len(pld_const_64qam.points())
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_diff_encoder_bb_0_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(pld_const_qpsk.points())
  states: {}
- name: digital_diff_encoder_bb_0_0_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_diff_encoder_bb_0_0_1
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(pld_const_16qam.points())
  states: {}
- name: digital_diff_encoder_bb_0_0_1_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(pld_const_64qam.points())
  states: {}
- name: digital_diff_encoder_bb_0_1
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_diff_encoder_bb_0_2
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_diff_encoder_bb_0_2_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: len(hdr_const.points())
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '256'
    rolloff: eb
    samps_per_sym: sps
    type: cc
    w: '2e-3'
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: pld_const_64qam
    mu: '1e-9'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_lms_dd_equalizer_cc_2_0_0_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: pld_const_16qam
    mu: '1e-9'
    num_taps: '15'
    sps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw*2
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format_qpsk
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format_bpsk
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_0_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format_16qam
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_formatter_bb_0_0_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format_64qam
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format_bpsk_copy
  states: {}
- name: fec_generic_decoder_0_0
  id: fec_generic_decoder
  parameters:
    decoder: dec_dummy
    itype: float
    otype: byte
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.psk_constellation(2,digital.mod_codes.GRAY_CODE)
  states: {}
- name: hdr_format_16qam
  id: parameter
  parameters:
    label: Header Formatter
    value: TFMv5.header_format_counter_dif(digital.packet_utils.default_access_code, 0,4)
  states: {}
- name: hdr_format_64qam
  id: parameter
  parameters:
    label: Header Formatter
    value: TFMv5.header_format_counter_dif(digital.packet_utils.default_access_code, 0,6)
  states: {}
- name: hdr_format_bpsk
  id: parameter
  parameters:
    label: Header Formatter
    value: TFMv5.header_format_counter_dif(digital.packet_utils.default_access_code, 0,1)
  states: {}
- name: hdr_format_bpsk_copy
  id: parameter
  parameters:
    label: Header Formatter
    value: TFMv5.header_format_counter_dif(digital.packet_utils.default_access_code, 0,1)
  states: {}
- name: hdr_format_qpsk
  id: parameter
  parameters:
    label: Header Formatter
    value: TFMv5.header_format_counter_dif(digital.packet_utils.default_access_code, 0,2)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import TFMv5
  states: {}
- name: mod_header_0_0
  id: virtual_sink
  parameters:
    stream_id: Header
  states: {}
- name: mod_header_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload QPSK
  states: {}
- name: mod_header_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload BPSK
  states: {}
- name: mod_header_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload 16QAM
  states: {}
- name: mod_header_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload 64QAM
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: sps
    samp_delay: filt_delay
    taps: psf_taps
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: sps
    samp_delay: filt_delay
    taps: psf_taps
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: sps
    samp_delay: filt_delay
    taps: psf_taps
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: sps
    samp_delay: filt_delay
    taps: psf_taps
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: Const
    name: '"Header Constellation"'
    size: '128'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: Const
    name: '"QPSK"'
    size: '512'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: Const
    name: '"BPSK"'
    size: '128'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,1,1,1
    label1: Const
    name: '"16QAM"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,0,1,1
    label1: Const
    name: '"64QAM"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    name: '"Tx Signal"'
    size: 1024*10
    srate: 1e6
    tr_tag: ''
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1,1,1
    name: '"Ph Clock Out"'
    size: 1024*4
    srate: 1e6
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rx_mod_header_0_0
  id: virtual_source
  parameters:
    stream_id: Header
  states: {}
- name: rx_mod_header_0_1
  id: virtual_source
  parameters:
    stream_id: Payload QPSK
  states: {}
- name: rx_mod_header_0_1_0
  id: virtual_source
  parameters:
    stream_id: Payload BPSK
  states: {}
- name: rx_mod_header_0_1_1
  id: virtual_source
  parameters:
    stream_id: Payload 16QAM
  states: {}
- name: rx_mod_header_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: Payload 64QAM
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"serial=30F9A69"'
    dev_args: '""'
    gain0: gain_tx
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: disabled
    dev_addr: '"serial=30F9A6B"'
    dev_args: '""'
    gain0: gain_rx
    iq_imbal_enb0: disabled
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Header Bytes QPSK
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Header Bytes BPSK
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bytes BPSK
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bytes QPSK
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bytes 16QAM
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bytes 64QAM
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Header Bytes 16QAM
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Header Bytes 64QAM
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: Tx Symbols QPSK
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Tx Symbols BPSK
  states: {}
- name: virtual_sink_0_1_1
  id: virtual_sink
  parameters:
    stream_id: Tx Symbols 16QAM
  states: {}
- name: virtual_sink_0_1_1_0
  id: virtual_sink
  parameters:
    stream_id: Tx Symbols 64QAM
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Dispersion BPSK
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Dispersion QPSK
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Dispersion 16QAM
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Dispersion 64QAM
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: BPSK Info
  states: {}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: QPSK Info
  states: {}
- name: virtual_sink_1_1_0_0
  id: virtual_sink
  parameters:
    stream_id: 16QAM Info
  states: {}
- name: virtual_sink_1_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: 64QAM Info
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bytes QPSK
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bytes QPSK
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bytes BPSK
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: Payload Bytes 16QAM
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: Payload Bytes 64QAM
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Header Bytes 16QAM
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: Tx Symbols QPSK
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: Tx Symbols 16QAM
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Tx Symbols 64QAM
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: Tx Symbols BPSK
  states: {}
- name: virtual_source_0_1_2
  id: virtual_source
  parameters:
    stream_id: Header Bytes 64QAM
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: Header Bytes BPSK
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: BPSK Info
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: QPSK Info
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: 16QAM Info
  states: {}
- name: virtual_source_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: 64QAM Info
  states: {}

connections:
- [TFMv5_dispersion_probe_0_1_0_0, threshold, virtual_sink_1, '0']
- [TFMv5_dispersion_probe_0_1_0_0_0, threshold, virtual_sink_1_0, '0']
- [TFMv5_dispersion_probe_0_1_0_0_0_0, threshold, virtual_sink_1_0_0, '0']
- [TFMv5_dispersion_probe_0_1_0_0_0_0_0, threshold, virtual_sink_1_0_0_0, '0']
- [TFMv5_energy_scale_0, '0', digital_fll_band_edge_cc_0, '0']
- [TFMv5_header_payload_demux_am_0, '0', mod_header_0_0, '0']
- [TFMv5_header_payload_demux_am_0, '1', mod_header_0_0_0_0, '0']
- [TFMv5_header_payload_demux_am_0, '2', mod_header_0_0_0, '0']
- [TFMv5_header_payload_demux_am_0, '3', mod_header_0_0_0_0_0, '0']
- [TFMv5_header_payload_demux_am_0, '4', mod_header_0_0_0_0_0_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_random_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [analog_random_source_x_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [analog_random_source_x_0_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_tagged_stream_mux_0_1_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', digital_cma_equalizer_cc_0_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', digital_lms_dd_equalizer_cc_2_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_tagged_stream_mux_0_1, '1']
- [blocks_repack_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_diff_encoder_bb_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_diff_encoder_bb_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_1, '0', digital_diff_encoder_bb_0_0_1, '0']
- [blocks_repack_bits_bb_0_0_1_0, '0', digital_diff_encoder_bb_0_0_1_0, '0']
- [blocks_repack_bits_bb_0_1, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_repack_bits_bb_0_1_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_0_1_1, '0', blocks_tagged_stream_to_pdu_0_1, '0']
- [blocks_repack_bits_bb_0_1_1_0, '0', blocks_tagged_stream_to_pdu_0_1_0, '0']
- [blocks_repack_bits_bb_0_2, '0', digital_diff_encoder_bb_0_1, '0']
- [blocks_repack_bits_bb_0_3, '0', digital_diff_encoder_bb_0_2, '0']
- [blocks_repack_bits_bb_0_3_0, '0', digital_diff_encoder_bb_0_2_0, '0']
- [blocks_selector_0, '0', channels_channel_model_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', digital_crc32_bb_0_0_0_0, '0']
- [blocks_tag_gate_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0, '0', pfb_arb_resampler_xxx_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0_0, '0', pfb_arb_resampler_xxx_0_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0_0_0, '0', pfb_arb_resampler_xxx_0_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_1, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_1_0, '0']
- [blocks_tagged_stream_mux_0_1, '0', virtual_sink_0_1_1, '0']
- [blocks_tagged_stream_mux_0_1_0, '0', virtual_sink_0_1_1_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, virtual_sink_1_1_0, '0']
- [blocks_tagged_stream_to_pdu_0_0, pdus, virtual_sink_1_1, '0']
- [blocks_tagged_stream_to_pdu_0_1, pdus, virtual_sink_1_1_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_1_0, pdus, virtual_sink_1_1_0_0_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [digital_chunks_to_symbols_xx_0_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [digital_chunks_to_symbols_xx_0_0_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [digital_chunks_to_symbols_xx_0_2, '0', blocks_tagged_stream_mux_0_1, '0']
- [digital_chunks_to_symbols_xx_0_2_0, '0', blocks_tagged_stream_mux_0_1_0, '0']
- [digital_cma_equalizer_cc_0_0_0, '0', TFMv5_header_payload_demux_am_0, '0']
- [digital_cma_equalizer_cc_0_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_cma_equalizer_cc_0_0_0_0_0, '0', digital_costas_loop_cc_0_0_0_0, '0']
- [digital_cma_equalizer_cc_0_0_0_0_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_cma_equalizer_cc_0_0_0_1, '0', digital_lms_dd_equalizer_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0_0_2_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0_1, '0']
- [digital_constellation_decoder_cb_0_0_1, '0', digital_diff_decoder_bb_0_0_0_2, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '4', TFMv5_dispersion_probe_0_1_0_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '4', digital_constellation_decoder_cb_0_0_1, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0_0_1, '0']
- [digital_constellation_receiver_cb_0_0, '0', blocks_null_sink_0_1, '0']
- [digital_constellation_receiver_cb_0_0, '1', blocks_null_sink_0_0_1, '0']
- [digital_constellation_receiver_cb_0_0, '2', blocks_null_sink_0_0_0_1, '0']
- [digital_constellation_receiver_cb_0_0, '3', blocks_null_sink_0_0_0_0_0, '0']
- [digital_constellation_receiver_cb_0_0, '4', TFMv5_dispersion_probe_0_1_0_0_0_0_0, '0']
- [digital_constellation_receiver_cb_0_0, '4', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_receiver_cb_0_0, '4', qtgui_const_sink_x_0_0_1_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_generic_decoder_0_0, '0']
- [digital_corr_est_cc_0, '0', blocks_tag_gate_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', TFMv5_dispersion_probe_0_1_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_0_0_0, '0', TFMv5_dispersion_probe_0_1_0_0, '0']
- [digital_costas_loop_cc_0_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_0_0_0, '0']
- [digital_crc32_bb_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', virtual_sink_0_0_0_0, '0']
- [digital_crc32_bb_0_0_0, '0', digital_protocol_formatter_bb_0_0_0, '0']
- [digital_crc32_bb_0_0_0, '0', virtual_sink_0_0_0_0_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', digital_protocol_formatter_bb_0_0_0_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', virtual_sink_0_0_0_0_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_diff_decoder_bb_0_0_0_0, '0', digital_protocol_parser_b_0, '0']
- [digital_diff_decoder_bb_0_0_0_1, '0', blocks_repack_bits_bb_0_1_0, '0']
- [digital_diff_decoder_bb_0_0_0_2, '0', blocks_repack_bits_bb_0_1_1, '0']
- [digital_diff_decoder_bb_0_0_0_2_0, '0', blocks_repack_bits_bb_0_1_1_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_diff_encoder_bb_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [digital_diff_encoder_bb_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [digital_diff_encoder_bb_0_0_1, '0', digital_chunks_to_symbols_xx_0_0_1, '0']
- [digital_diff_encoder_bb_0_0_1_0, '0', digital_chunks_to_symbols_xx_0_0_1_0, '0']
- [digital_diff_encoder_bb_0_1, '0', digital_chunks_to_symbols_xx_0_1, '0']
- [digital_diff_encoder_bb_0_2, '0', digital_chunks_to_symbols_xx_0_2, '0']
- [digital_diff_encoder_bb_0_2_0, '0', digital_chunks_to_symbols_xx_0_2_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_corr_est_cc_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_constellation_receiver_cb_0_0, '0']
- [digital_lms_dd_equalizer_cc_2_0_0_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', virtual_sink_0_0, '0']
- [digital_protocol_formatter_bb_0_0_0, '0', virtual_sink_0_0_1, '0']
- [digital_protocol_formatter_bb_0_0_0_0, '0', virtual_sink_0_0_1_0, '0']
- [digital_protocol_parser_b_0, info, TFMv5_header_payload_demux_am_0, header_data]
- [fec_generic_decoder_0_0, '0', digital_diff_decoder_bb_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', blocks_selector_0, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', blocks_selector_0, '1']
- [pfb_arb_resampler_xxx_0_0_0_0, '0', blocks_selector_0, '2']
- [pfb_arb_resampler_xxx_0_0_0_0_0, '0', blocks_selector_0, '3']
- [rx_mod_header_0_0, '0', digital_cma_equalizer_cc_0_0_0_0, '0']
- [rx_mod_header_0_1, '0', digital_cma_equalizer_cc_0_0_0_0_0_0, '0']
- [rx_mod_header_0_1_0, '0', digital_cma_equalizer_cc_0_0_0_0_0, '0']
- [rx_mod_header_0_1_1, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [rx_mod_header_0_1_1_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', TFMv5_energy_scale_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0, '0']
- [virtual_source_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [virtual_source_0_0_1, '0', blocks_repack_bits_bb_0_0_1, '0']
- [virtual_source_0_0_1_0, '0', blocks_repack_bits_bb_0_0_1_0, '0']
- [virtual_source_0_1, '0', blocks_repack_bits_bb_0_3, '0']
- [virtual_source_0_1_0, '0', blocks_tagged_stream_multiply_length_0_0_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_tagged_stream_multiply_length_0_0_0_0, '0']
- [virtual_source_0_1_0_0_0, '0', blocks_tagged_stream_multiply_length_0_0_0_0_0, '0']
- [virtual_source_0_1_1, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [virtual_source_0_1_2, '0', blocks_repack_bits_bb_0_3_0, '0']
- [virtual_source_0_2, '0', blocks_repack_bits_bb_0_2, '0']
- [virtual_source_2, '0', TFMv5_crc32_check_0, in]
- [virtual_source_2_0, '0', TFMv5_crc32_check_0, in]
- [virtual_source_2_0_0, '0', TFMv5_crc32_check_0, in]
- [virtual_source_2_0_0_0, '0', TFMv5_crc32_check_0, in]

metadata:
  file_format: 1
